# Keil uVision project WELD_E_PRO.uvprojx, settings and files
target WELD_E_PRO (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: WELD_E_PRO
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c misc: --cpp11
  c include: ..\LIB\SPL\inc;..\_BSP;..\_COR;..\_MSP;..\_USER;..\_SYS
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group PROCESS
    ../_PROCESS/: process.h process.c
  group APP
    ../_USER/: usercode.h usercode.c task.h task.c Interface.h Interface.c class_process_controller.h class_process_controller.cpp class_decode.h class_decode.cpp class_power.h class_power.cpp
  group SYS
    ../_SYS/: os.h os.c com.h com.c class_board.h class_board.cpp
  group BSP
    ../_BSP/: BSP_Config.h BSP_CORE.h BSP_CORE.c BSP_TIM.h BSP_TIM.c BSP_IO_OSLED.h BSP_IO_OSLED.c BSP_IO_ELECTRONIC.h BSP_IO_ELECTRONIC.c BSP_IO_MECHANICAL.h BSP_IO_MECHANICAL.c BSP_DAC.h BSP_DAC.c BSP_USART.h BSP_USART.c
  group MSP
    ../_MSP/: MSP_Config.h MSP_CORE_Config.h MSP_CORE_Config.c MSP_IO_ELECTRONIC_Config.h MSP_IO_ELECTRONIC_Config.c MSP_IO_MECHANICAL_Config.h MSP_IO_MECHANICAL_Config.c MSP_IO_OSLED_Config.h MSP_IO_OSLED_Config.c MSP_DAC_Config.h MSP_DAC_Config.c MSP_USART_Config.h MSP_USART_Config.c
  group COR
    ../_COR/: stm32f10x_conf.h startup_stm32f10x_cl.s stm32f10x.h core_cm3.c core_cm3.h system_stm32f10x.c system_stm32f10x.h utils.c utils.h
  group LIB-ST-SPL
    ../LIB/SPL/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
software components: CMSIS:CORE 4.3.0
